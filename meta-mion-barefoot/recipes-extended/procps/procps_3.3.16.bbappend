# SPDX-License-Identifier: MIT

FILESEXTRAPATHS_append := "${THISDIR}/files:"
