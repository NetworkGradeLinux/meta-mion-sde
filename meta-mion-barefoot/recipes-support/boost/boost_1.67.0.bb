require boost-${PV}.inc
require boost.inc

SRC_URI += "\
    file://0002-Don-t-set-up-m32-m64-we-do-that-ourselves.patch \
"
